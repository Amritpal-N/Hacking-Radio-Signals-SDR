options:
  parameters:
    generate_options: qt_gui
    id: record_signal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\User\Desktop\capture
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '16'
    freq0: 100e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
